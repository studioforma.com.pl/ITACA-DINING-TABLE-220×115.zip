Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Dining Table 220x115 - ver4.ifc
Time: 2025-11-13T16:17:57
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Itaca-Dining Table 220x115_0 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_1 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_2 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_3 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_4 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_5 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_6 - ObjectType: SketchupGroup
 | Itaca-Dining Table 220x115_7 - ObjectType: SketchupGroup
